# IAR project DIM_2955.ewp, settings and files
configuration DIM_Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430G2955 MSP430G2955
  General.GStackSize2: 120
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __DEBUG_MODE__; __EXTERNAL_DIM__
  ICC430.newCCIncludePaths: ; ..\; ..\..\..\API\; ..\..\..\DRV\; ..\..\..\COMMON\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2955.xcl
  XLINK.XlinkStackSize: 1
configuration DIM_Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __EXTERNAL_DIM__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955.xcl
configuration DIM_PART1 (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __EXTERNAL_DIM__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955_1.xcl
configuration DIM_PART2 (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __EXTERNAL_DIM__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955_2.xcl
configuration DIM_2X_DEBUG (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __DEBUG_MODE__; __2X__; __EXTERNAL_DIM__
configuration DIM_2X_RELEASE (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __2X__; __EXTERNAL_DIM__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955.xcl
configuration DIM_2X_PART1 (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __2X__; __EXTERNAL_DIM__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955_1.xcl
configuration DIM_2X_PART2 (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __2X__; __EXTERNAL_DIM__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955_2.xcl
configuration DIM_DRIPTRAY_Debug (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __DEBUG_MODE__
configuration DIM_DRIPTRAY_Release (MSP430)
  as the first configuration, except:
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955.xcl
configuration DIM_DRIPTRAY_PART1 (MSP430)
  as the first configuration, except:
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955_1.xcl
configuration DIM_DRIPTRAY_PART2 (MSP430)
  as the first configuration, except:
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955_2.xcl
configuration DIM_DRIPTRAY_2X_DEBUG (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __DEBUG_MODE__; __2X__
configuration DIM_DRIPTRAY_2X_RELEASE (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __2X__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955.xcl
configuration DIM_DRIPTRAY_2X_PART1 (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __2X__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955_1.xcl
configuration DIM_DRIPTRAY_2X_PART2 (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __2X__
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430g2955_2.xcl
  group (top)
    ../../../DRV/: ccxx2x_drv.c flash_drv.c i2c_drv.c rf_spi_drv.c timer_drv.c
    ./: dfu.c dim.c flash_app.c io.c lf.c main.c motion.c profile.c rf_app.c
    ../../../COMMON/: general.c rf.c
